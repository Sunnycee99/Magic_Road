# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\user;.\NET\onenet\inc;.\NET\MQTT;.\NET\device\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c
  group hardware
    ./hardware/src/: beep.c delay.c usart.c lsensor.c led.c ds18b20.c pm2_5.c
  group user
    ./user/: main.c
  group OneNET
    ./NET/onenet/src/: onenet.c
  group net_protocol
    ./NET/MQTT/: MqttKit.c
  group net_device
    ./NET/device/src/: esp8266.c
software components: CMSIS:CORE 4.3.0
